# Keil uVision project C51.uvproj, settings and files
target Demo (MCS-51)
  device: AT89C52 Atmel
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
